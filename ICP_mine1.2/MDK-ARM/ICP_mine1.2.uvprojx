# Keil uVision project ICP_mine1.2.uvprojx, settings and files
target ICP_mine1.2 (ARM-ADS)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: ICP_mine1.2
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include;..\RAKSDK\examples_os;..\RAKSDK\rw_lib;..\RAKSDK\common\include;..\RAKSDK\bsp;..\Hardware\AD7606;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;..\Hardware\bluetooth;..\OS_task\my_task;..\OS_task\my_queue;../Middlewares/Third_Party/FatFs/src;..\Hardware\my_fatfs;..\Hardware\lua-5.3.4\src;..\Hardware\stubs;..\Hardware\lua-5.3.4\user;..\Hardware\lua_rtos;..\Hardware\lua_rtos\pthread;..\Hardware\lua_rtos\lua_adds;..\Hardware\lua_rtos\lua_adds\modules;..\Hardware\lua_rtos\Freertos_adds
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c queue.c list.c tasks.c croutine.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Application/User
    ../Src/: freertos.c stm32f4xx_hal_timebase_TIM.c usart.c stm32f4xx_it.c tim.c gpio.c main.c stm32f4xx_hal_msp.c adc.c spi.c usbd_desc.c usbd_cdc_if.c usbd_conf.c usb_device.c sdio.c dma.c sd_diskio.c bsp_driver_sd.c fatfs.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pcd.c stm32f4xx_ll_usb.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c
  group RAK_SDK/platform/bsp_os
    ../RAKSDK/bsp/: bsp.c
  group RAK_SDK/rw_lib
    ../RAKSDK/rw_lib/: rw_lib_platform_os.c rw_os.c
    ../RAKSDK/rw_lib/RAK439_DriverLibs_V1.0.7/MDK_ARM/: rak_wifi_os_ARM_CM4F.lib
  group RAK_SDK/common/include
    ../RAKSDK/common/include/: rw_error.h rw_lib.h rw_socket.h
  group RAK_SDK/examples_os/tcp_udp
    ../RAKSDK/examples_os/: ap_sta.c tcp_udp.c
  group Hardware/AD7606
    ../Hardware/AD7606/: ad7606.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_core.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Hardware/Bluetooth
    ../Hardware/bluetooth/: bluetooth.c
  group OS_task/my_task
    ../OS_task/my_task/: my_task.c task_utilities.c
  group OS_task/my_queue
    ../OS_task/my_queue/: my_queue.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
  group Hardware/my_fatfs
    ../Hardware/my_fatfs/: my_fatfs.c
  group LuaSDK/src
    ../Hardware/lua-5.3.4/src/: lapi.c lauxlib.c lbaselib.c lbitlib.c lcode.c lcorolib.c lctype.c ldblib.c ldebug.c ldo.c ldump.c lfunc.c lgc.c linit.c liolib.c llex.c lmathlib.c lmem.c loadlib.c lobject.c lopcodes.c loslib.c lparser.c lstate.c lstring.c lstrlib.c ltable.c ltablib.c ltm.c lundump.c lutf8lib.c lvm.c lzio.c
  group LuaSDK/user
    ../Hardware/lua-5.3.4/user/: stm32_lua_config.c lua_test.c mmcfs.c
  group Stubs
    ../Hardware/stubs/: my_malloc.c xprint_init.c xprintf.c
    ../Hardware/lua-5.3.4/user/: my_debug.c
  group lua_rtos/pthread
    ../Hardware/lua_rtos/pthread/: attr.c cleanup.c cond.c create.c join.c key.c mutex.c once.c pthread.c self.c
  group lua_rtos/sys
    ../Hardware/lua_rtos/sys/: mutex_sys.c panic_sys.c status.c debug.h
    ../Hardware/lua_rtos/sys/list/: list_sys.c
  group lua_rtos/lua_adds
    ../Hardware/lua_rtos/lua_adds/Luac/: lua.c
    ../Hardware/lua_rtos/lua_adds/: lua_adds.h Lua_modules.h my_luaconf.h
  group lua_rtos/modules
    ../Hardware/lua_rtos/lua_adds/modules/: auxmods.h lgpiolib.c thread.c thread.h makeparam.h pio.h linenoise.c linenoise.h tmr.c machine.c lhardwrae.c
  group lua_rtos/freeertos_adds
    ../Hardware/lua_rtos/Freertos_adds/: portmacro_add.h tasks_adds.h
  group lua_rtos/board_def
    ../Hardware/lua_rtos/: usleep.c Lua_test_thread.c myBoardDef.h
software components: CMSIS:CORE 4.1.0
